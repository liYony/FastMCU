# Keil uVision project project.uvprojx, settings and files
target stm32f407 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f407
  AfterMake: fromelf --bin !L --output stm32f407.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F407xx
  c include: board;drivers;libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\components\lwip\port;.;..\..\..\components\lwip\lwip-2.1.2\src\include\netif;..\..\..\include;..\..\..\drivers\include;..\..\..\components\lwip\lwip-2.1.2\src\include;libraries\CMSIS\Include;libraries\STM32F4xx_HAL_Driver\Inc;applications
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group applications
    applications/: main.c
  group board
    libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
    board/: stm32f4xx_it.c
  group dal
    ../../../drivers/: dal_timer.c dal_spi.c dal_pwm.c dal_flash.c dal_system.c dal_gpio.c dal_adc.c dal_it.c dal_uart.c
  group libraries
    libraries/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_uart.c stm32f4xx_hal.c stm32f4xx_hal_crc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_usart.c stm32f4xx_hal_pwr.c stm32f4xx_hal_gpio.c stm32f4xx_hal_cec.c stm32f4xx_hal_dma.c stm32f4xx_hal_cryp_ex.c
    libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group lwip/api
    ../../../components/lwip/lwip-2.1.2/src/api/: api_lib.c err.c netbuf.c if_api.c tcpip.c api_msg.c netifapi.c netdb.c sockets.c
  group lwip/arch
    ../../../components/lwip/port/: sys_arch.c
  group lwip/core
    ../../../components/lwip/lwip-2.1.2/src/core/: netif.c memp.c altcp_alloc.c timeouts.c def.c init.c altcp_tcp.c dns.c tcp_out.c inet_chksum.c sys.c ip.c altcp.c stats.c tcp.c raw.c udp.c pbuf.c mem.c tcp_in.c
    ../../../components/lwip/lwip-2.1.2/src/core/ipv4/: ip4_frag.c etharp.c dhcp.c ip4_addr.c autoip.c igmp.c icmp.c ip4.c
  group lwip/netif
    ../../../components/lwip/lwip-2.1.2/src/netif/: ethernet.c lowpan6.c
  group mcu
    drivers/: mcu_system.c mcu_uart.c
  group src
    ../../../src/: fm_log.c fm_section.c
