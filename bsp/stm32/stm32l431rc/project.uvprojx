# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L431RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00004000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER, STM32L431xx
  c include: libraries\CMSIS\Include;..\..\..\utils\include;board;libraries\STM32L4xx_HAL_Driver\Inc;applications;drivers;libraries\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\drivers\include;.;..\..\..\include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x4000
  group applications
    applications/: main.c
  group board
    board/: stm32l4xx_it.c
    libraries/CMSIS/Device/ST/STM32L4xx/Source/Templates/arm/: startup_stm32l431xx.s
  group dal
    ../../../drivers/: dal_it.c dal_system.c dal_gpio.c dal_uart.c
  group libraries
    libraries/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_cortex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_exti.c stm32l4xx_hal_crc.c stm32l4xx_hal_uart.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_comp.c stm32l4xx_hal_usart.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_cryp.c
    libraries/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
  group mcu
    drivers/: mcu_uart.c mcu_system.c
  group src
    ../../../src/: qk_log.c qk_section.c
  group utils
    ../../../utils/: qk_state.c qk_urc.c
