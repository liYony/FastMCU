# Keil uVision project project.uvprojx, settings and files
target MS200 (6140000::V6.14::ARMCLANG)
  device: GD32F310G8 GigaDevice
  pack: GigaDevice.GD32F3x0_DFP.3.0.2
  cpu: IRAM(0x20000000,0x02000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MS200
  AfterMake: fromelf --bin !L --output MS200.bin
  c flags: uC99=1 v6Lang=1 v6LangP=1
  c define: GD32F310, GD32F3X0
  c include: applications;..\..\..\include;..\..\..\drivers\include;.;libraries;drivers;libraries\GD32E23x_standard_peripheral\Include;libraries\CMSIS\GD\GD32E23x\Include;board;..\..\..\utils\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group applications
    applications/: main.c
  group board
    board/: gd32f3x0_it.c
    libraries/CMSIS/GD/GD32E23x/Source/ARM/: startup_gd32f3x0.s
  group dal
    ../../../drivers/: dal_it.c dal_uart.c dal_system.c
  group libraries
    libraries/GD32E23x_standard_peripheral/Source/: gd32f3x0_usart.c gd32f3x0_adc.c gd32f3x0_fwdgt.c gd32f3x0_spi.c gd32f3x0_pmu.c gd32f3x0_timer.c gd32f3x0_rcu.c gd32f3x0_syscfg.c gd32f3x0_fmc.c gd32f3x0_exti.c gd32f3x0_misc.c gd32f3x0_gpio.c gd32f3x0_dma.c
    libraries/CMSIS/GD/GD32E23x/Source/: system_gd32f3x0.c
  group mcu
    drivers/: mcu_system.c mcu_uart.c
  group src
    ../../../src/: qk_log.c qk_section.c
  group utils
    ../../../utils/: qk_state.c qk_urc.c
software components: CMSIS:CORE 5.4.0
