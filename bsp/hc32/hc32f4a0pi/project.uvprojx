# Keil uVision project project.uvprojx, settings and files
target hc32f4a0 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: HC32F4A0PITB HDSC
  pack: HDSC.HC32F4A0.1.0.7
  cpu: IRAM(0x1FFE0000,0x80000) IROM(0x00000000,0x200000) IROM2(0x03000000,0x1800) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: hc32f4a0
  AfterMake: fromelf --bin !L --output hc32f4a0.bin
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: HC32F4A0, USE_DDL_DRIVER
  c include: ..\..\..\include;libraries\cmsis\Include;..\..\..\components\network\lwip\port;.;..\..\..\drivers\include;libraries\cmsis\Device\HDSC\hc32f4xx\Include;..\..\..\components\network\lwip\lwip-2.1.2\src\include\netif;libraries\hc32_ll_driver\inc;applications;..\..\..\components\network\lwip\lwip-2.1.2\src\include;drivers;board
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x3000000 size 0x1800
  memory RVCT9: RAM 0x1ffe0000 size 0x80000
  group applications
    applications/: main.c
  group board
    board/: board_config.c
    libraries/cmsis/Device/HDSC/hc32f4xx/Source/ARM/: startup_hc32f4a0.s
  group dal
    ../../../drivers/: dal_gpio.c dal_timer.c dal_system.c dal_it.c dal_uart.c dal_spi.c dal_pwm.c
  group libraries
    libraries/hc32_ll_driver/src/: hc32_ll_dvp.c hc32_ll_ctc.c hc32_ll_ots.c hc32_ll_pwc.c hc32_ll_cmp.c hc32_ll_qspi.c hc32_ll_dma.c hc32_ll_trng.c hc32_ll_eth.c hc32_ll_interrupts.c hc32_ll_adc.c hc32_ll_i2s.c hc32_ll_tmr0.c hc32_ll_rtc.c hc32_ll_aos.c hc32_ll_fmac.c hc32_ll_sdioc.c hc32_ll_efm.c hc32_ll_dmc.c hc32_ll_sram.c hc32_ll_mau.c hc32_ll_smc.c hc32_ll_keyscan.c hc32_ll_spi.c hc32_ll_nfc.c hc32_ll.c hc32_ll_usb.c hc32_ll_fcm.c hc32_ll_crc.c hc32_ll_fcg.c hc32_ll_can.c hc32_ll_utility.c hc32_ll_emb.c hc32_ll_dcu.c hc32_ll_tmr4.c hc32_ll_rmu.c hc32f4a0_ll_interrupts_share.c hc32_ll_event_port.c hc32_ll_tmra.c hc32_ll_mpu.c hc32_ll_dac.c hc32_ll_hash.c hc32_ll_tmr2.c hc32_ll_clk.c hc32_ll_tmr6.c hc32_ll_aes.c hc32_ll_usart.c hc32_ll_i2c.c hc32_ll_gpio.c hc32_ll_wdt.c hc32_ll_hrpwm.c hc32_ll_swdt.c hc32_ll_icg.c
    libraries/cmsis/Device/HDSC/hc32f4xx/Source/: system_hc32f4a0.c
  group lwip
    ../../../components/network/lwip/port/: ethernetif.c
  group lwip/api
    ../../../components/network/lwip/lwip-2.1.2/src/api/: if_api.c netdb.c netifapi.c api_msg.c api_lib.c tcpip.c sockets.c err.c netbuf.c
  group lwip/core
    ../../../components/network/lwip/lwip-2.1.2/src/core/: altcp.c stats.c raw.c tcp_in.c altcp_tcp.c dns.c pbuf.c timeouts.c init.c inet_chksum.c mem.c memp.c sys.c udp.c tcp.c ip.c tcp_out.c netif.c def.c altcp_alloc.c
    ../../../components/network/lwip/lwip-2.1.2/src/core/ipv4/: igmp.c ip4_addr.c ip4_frag.c autoip.c ip4.c etharp.c icmp.c dhcp.c
  group lwip/netif
    ../../../components/network/lwip/lwip-2.1.2/src/netif/: lowpan6.c ethernet.c
  group mcu
    drivers/: mcu_spi.c mcu_timer.c mcu_gpio.c mcu_eth.c mcu_system.c mcu_pwm.c
  group src
    ../../../src/: fm_log.c fm_section.c fm_timer.c
