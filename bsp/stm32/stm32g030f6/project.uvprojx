# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32G030F6Px STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER, USE_FULL_LL_DRIVER, STM32G030xx
  c include: ..\..\..\drivers\include;libraries\CMSIS\Device\ST\STM32G0xx\Include;libraries\CMSIS\Include;drivers;libraries\STM32G0xx_HAL_Driver\Inc;.;board;..\..\..\include;applications
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group applications
    applications/: main.c
  group board
    board/: stm32g0xx_it.c
    libraries/CMSIS/Device/ST/STM32G0xx/Source/Templates/arm/: startup_stm32g030xx.s
  group dal
    ../../../drivers/: dal_flash.c dal_pwm.c dal_adc.c dal_gpio.c dal_uart.c dal_system.c dal_timer.c dal_spi.c dal_it.c
  group libraries
    libraries/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_spi_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_adc_ex.c stm32g0xx_ll_adc.c stm32g0xx_hal_uart.c stm32g0xx_hal_dma_ex.c stm32g0xx_ll_tim.c stm32g0xx_hal_dma.c stm32g0xx_hal_rcc.c stm32g0xx_ll_gpio.c stm32g0xx_hal_spi.c stm32g0xx_hal_cortex.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_gpio.c stm32g0xx_ll_rcc.c stm32g0xx_hal_cec.c stm32g0xx_ll_spi.c stm32g0xx_hal_adc.c stm32g0xx_hal.c stm32g0xx_ll_usart.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_uart_ex.c stm32g0xx_hal_flash.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_usart_ex.c
    libraries/CMSIS/Device/ST/STM32G0xx/Source/Templates/: system_stm32g0xx.c
  group mcu
    drivers/: mcu_adc.c mcu_system.c mcu_gpio.c mcu_uart.c mcu_spi.c
  group src
    ../../../src/: fm_log.c fm_section.c
