# Keil uVision project template.uvprojx, settings and files
target MS200 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: GD32F310G8 GigaDevice
  pack: GigaDevice.GD32F3x0_DFP.3.0.2
  cpu: IRAM(0x20000000,0x02000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MS200
  AfterMake: fromelf --bin !L --output MS200.bin
  c flags: uC99=1 v6Lang=1 v6LangP=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
software components: CMSIS:CORE 5.4.0
